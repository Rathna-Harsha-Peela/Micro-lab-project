PUBLIC MAC
CSEG AT 100H

MAC:
// MAC OPERATION, CALL THE ADDITION SUBROUTINE USING "CALL ADD16"
MOV R6,#00H
MOV  A,70H
MOV  B,73H
MUL AB
MOV R0,A
MOV R3,B

MOV  A,71H
MOV  B,74H
MUL AB
MOV R1,A
MOV R4,B

MOV  A,72H
MOV  B,75H
MUL AB
MOV 6EH,A
MOV 6FH,B
CALL ADD16
MOV R1,6EH
MOV R4,6FH
CALL ADD16
MOV 52H, R0
MOV 51H, R3
MOV 50H, R6
RET

ADD16:


MOV A, R0
ADD A, R1
MOV R0, A

MOV A, R3
ADDC A,R4
MOV R3, A

MOV A, #00H
ADDC A, R6
MOV R6, A
// ADD16 SUBROUTINE FROM PREVIOUS LAB
RET
END